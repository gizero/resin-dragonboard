inherit kernel-resin

