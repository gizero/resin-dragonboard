IMAGE_FSTYPES_append_dragonboard-410c = " resin-sdcard"

RESIN_IMAGE_BOOTLOADER = ""
